	AREA RESET, DATA, READONLY
	EXPORT __Vectors
__Vectors 
	DCD 0x10001000 ; stack pointer value when stack is empty
	DCD Reset_Handler ; reset vector
	ALIGN
	AREA mycode, CODE, READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R3,=SRC
	MOV R4,#10
	LDR R5,=DST
BACK LDR R1,[R3],#4
	ADDS R0,R1;
	ADC R2,#0
	SUBS R4,#1
	BNE BACK
	STR R0,[R5],#4
	STR R2,[R5]
STOP B STOP
SRC DCD 0XF00213C8 ,0X62ED8941 ,0XE26709CA ,0XA41CB022, 0X2467D211,0XFF1256CD,0X3C154230,0X87654321,0xFCA23180,0X4B31DCA4
	AREA mydata,DATA,READWRITE
DST DCD 0,0
	END